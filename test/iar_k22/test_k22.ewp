# IAR project test_k22.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CPU_MK22FN512VLH12; DEBUG; CLOCK_SETUP=1; ARM_MATH_CM4; __FPU_PRESENT=1
  ICCARM.CCDiagSuppress: Pa050,Pa082
  ICCARM.CCIncludePath2: src; ..\..\src\devices\MK22F51212; ..\..\src\ksdk; ..\..\src\CMSIS\Include; ..\..\src\argon\cortex_m; ..\..\src\argon\test; ..\..\src\argon\test\src; ..\..\src\argon; ..\..\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: CPU_MK22FN512VLH12
  ILINK.IlinkOutputFile: lowrider_k22.out
  ILINK.IlinkConfigDefines: __heap_size__=8192; __stack_size__=4096
  ILINK.IlinkIcfFile: ..\..\src\devices\MK22F51212\iar\MK22FN512xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group argon
    ../../src/argon/cortex_m/: ar_asm_macros.h ar_atomics_cm4.S ar_handlers_cm4.S ar_main_thread.cpp ar_port.cpp ar_port.h
    ../../src/argon/src/: ar_channel.cpp ar_config.h ar_internal.h ar_kernel.cpp ar_mutex.cpp ar_queue.cpp ar_runloop.cpp ar_sem.cpp ar_thread.cpp ar_timer.cpp
    ../../src/argon/: ar_classes.h ar_kernel.h argon.h
  group ksdk
    ../../src/ksdk/: fsl_adc16.c fsl_adc16.h fsl_common.c fsl_common.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_fxos.c fsl_fxos.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_port.h fsl_uart.c fsl_uart.h
  group src
    ../src/: runloop_test.cpp
  group startup
    ../../src/devices/MK22F51212/: fsl_clock.c fsl_clock.h system_MK22F51212.c system_MK22F51212.h
    ../../src/devices/MK22F51212/iar/: startup_MK22F51212.s
  group test
    ../../src/argon/test/src/: kernel_test.cpp test_mutex.cpp test_mutex.h test_queue.cpp test_queue.h test_sem.cpp test_sem.h test_sleep.cpp test_sleep.h
    ../../src/argon/test/: kernel_test.h
