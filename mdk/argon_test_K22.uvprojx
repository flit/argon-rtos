# Keil uVision project argon_test_K22.uvprojx, settings and files
target debug (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.2.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: argon_test_K22
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: CPU_MK22FN512VLH12 DEBUG TARGET_K22F TOOLCHAIN_ARM
  c include: ..\src;..\src\include;..\src\include\device;..\src\include\device\MK22F51212;..\src\startup;..\src\startup\MK22F51212;..\src\argon\cortex_m;..\src\drivers;..\src\mbed\hal;..\src\mbed\api;..\src\mbed\targets\TARGET_KPSDK_MCUS;..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_K22F;..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_K22F\MK22F51212;..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\utilities;..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\adc;..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\dac;..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\dspi;..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\enet;..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\flextimer;..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\gpio;..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\i2c;..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\llwu;..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\lptmr;..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\mcg;..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\osc;..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\pdb;..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\pit;..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\pmc;..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\port;..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\rtc;..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\sai;..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\sdhc;..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\sim;..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\smc;..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\uart;..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\wdog;..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\drivers\clock;..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\drivers\enet;..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\drivers\interrupt;..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\drivers\pit;..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\drivers\pit\common
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ..\src\linker\MK22F51212\arm\MK22FN512xxx12_flash.scf
  group argon
    ../src/argon/: ar_classes.h ar_kernel.h argon.h
    ../src/argon/src/: ar_channel.cpp ar_config.h ar_internal.h ar_kernel.cpp ar_mutex.cpp ar_queue.cpp ar_sem.cpp ar_thread.cpp ar_timer.cpp
    ../src/argon/cortex_m/: ar_main_thread.cpp ar_port.cpp ar_port.h ar_handlers_cm4.s
  group startup
    ../src/startup/: startup.c
    ../src/startup/MK22F51212/: system_MK22F51212.c
    ../src/startup/MK22F51212/arm/: startup_MK22F51212.s
  group mbed_common
    ../src/mbed/common/: assert.c board.c BusIn.cpp BusInOut.cpp BusOut.cpp CallChain.cpp CAN.cpp error.c Ethernet.cpp exit.c FileBase.cpp FileLike.cpp FilePath.cpp FileSystemLike.cpp FunctionPointer.cpp gpio.c I2C.cpp I2CSlave.cpp InterruptIn.cpp InterruptManager.cpp LocalFileSystem.cpp mbed_interface.c pinmap_common.c RawSerial.cpp retarget.cpp rtc_time.c semihost_api.c Serial.cpp SerialBase.cpp SPI.cpp SPISlave.cpp Stream.cpp Ticker.cpp Timeout.cpp Timer.cpp TimerEvent.cpp us_ticker_api.c wait_api.c
  group ksdk
    ../src/mbed/targets/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/utilities/src/: fsl_misc_utilities.c fsl_os_abstraction_mbed.c
    ../src/mbed/targets/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/adc/: fsl_adc_hal.c
    ../src/mbed/targets/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/dac/: fsl_dac_hal.c
    ../src/mbed/targets/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/dspi/: fsl_dspi_hal.c
    ../src/mbed/targets/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/flextimer/: fsl_ftm_hal.c
    ../src/mbed/targets/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/gpio/: fsl_gpio_hal.c
    ../src/mbed/targets/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/i2c/: fsl_i2c_hal.c
    ../src/mbed/targets/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/llwu/: fsl_llwu_hal.c
    ../src/mbed/targets/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/lptmr/: fsl_lptmr_hal.c
    ../src/mbed/targets/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/lpuart/: fsl_lpuart_hal.c
    ../src/mbed/targets/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/mcg/: fsl_mcg_hal.c fsl_mcg_hal_modes.c
    ../src/mbed/targets/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/osc/: fsl_osc_hal.c
    ../src/mbed/targets/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/pdb/: fsl_pdb_hal.c
    ../src/mbed/targets/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/pit/: fsl_pit_hal.c
    ../src/mbed/targets/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/pmc/: fsl_pmc_hal.c
    ../src/mbed/targets/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/port/: fsl_port_hal.c
    ../src/mbed/targets/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/rcm/: fsl_rcm_hal.c
    ../src/mbed/targets/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/rtc/: fsl_rtc_hal.c
    ../src/mbed/targets/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/sai/: fsl_sai_hal.c
    ../src/mbed/targets/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/sdhc/: fsl_sdhc_hal.c
    ../src/mbed/targets/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/sim/: fsl_sim_hal.c
    ../src/mbed/targets/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/smc/: fsl_smc_hal.c
    ../src/mbed/targets/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/uart/: fsl_uart_hal.c
    ../src/mbed/targets/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/wdog/: fsl_wdog_hal.c
    ../src/mbed/targets/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers/clock/: fsl_clock_manager.c
    ../src/mbed/targets/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers/pit/src/: fsl_pit_driver.c fsl_pit_irq.c
    ../src/mbed/targets/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers/pit/common/: fsl_pit_common.c
  group mbed_hal
    ../src/mbed/targets/TARGET_KPSDK_MCUS/: analogin_api.c analogout_api.c gpio_api.c gpio_irq_api.c gpio_object.h i2c_api.c objects.h PeripheralPins.h pinmap.c port_api.c PortNames.h pwmout_api.c rtc_api.c serial_api.c sleep.c spi_api.c us_ticker.c
  group k22f
    ../src/mbed/targets/TARGET_KPSDK_MCUS/TARGET_K22F/: cmsis_nvic.c mbed_overrides.c PeripheralPins.c
    ../src/mbed/targets/TARGET_KPSDK_MCUS/TARGET_K22F/MK22F51212/: fsl_clock_K22F51212.c fsl_sim_hal_K22F51212.c
  group test
    ../test/src/: basic_test.cpp kernel_tests.h test_mutex_1.cpp test_queue_1.cpp test_sem_1.cpp test_sleep_1.cpp
