<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>src</name>
    <group>
      <name>argon</name>
      <group>
        <name>cortex_m</name>
        <file>
          <name>$PROJ_DIR$\..\src\argon\cortex_m\ar_handlers_cm4.s</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\argon\cortex_m\ar_main_thread.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\argon\cortex_m\ar_port.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\argon\cortex_m\ar_port.h</name>
        </file>
      </group>
      <group>
        <name>src</name>
        <file>
          <name>$PROJ_DIR$\..\src\argon\src\ar_channel.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\argon\src\ar_config.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\argon\src\ar_internal.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\argon\src\ar_kernel.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\argon\src\ar_mutex.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\argon\src\ar_queue.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\argon\src\ar_sem.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\argon\src\ar_thread.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\argon\src\ar_timer.cpp</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\src\argon\ar_classes.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\argon\ar_kernel.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\argon\argon.h</name>
      </file>
    </group>
    <group>
      <name>drivers</name>
    </group>
    <group>
      <name>include</name>
      <file>
        <name>$PROJ_DIR$\..\src\include\fsl_platform_common.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\include\fsl_platform_status.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\include\fsl_platform_types.h</name>
      </file>
    </group>
    <group>
      <name>mbed</name>
      <group>
        <name>common</name>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\assert.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\board.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\BusIn.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\BusInOut.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\BusOut.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\CallChain.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\CAN.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\error.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\Ethernet.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\exit.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\FileBase.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\FileLike.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\FilePath.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\FileSystemLike.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\FunctionPointer.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\gpio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\I2C.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\I2CSlave.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\InterruptIn.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\InterruptManager.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\LocalFileSystem.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\mbed_interface.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\pinmap_common.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\RawSerial.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\retarget.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\rtc_time.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\semihost_api.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\Serial.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\SerialBase.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\SPI.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\SPISlave.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\Stream.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\Ticker.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\Timeout.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\Timer.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\TimerEvent.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\us_ticker_api.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\wait_api.c</name>
        </file>
      </group>
      <group>
        <name>k22F</name>
        <group>
          <name>ksdk</name>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\adc\fsl_adc_hal.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\drivers\clock\fsl_clock_manager.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\dac\fsl_dac_hal.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\dspi\fsl_dspi_hal.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\dspi\fsl_dspi_hal.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\flextimer\fsl_ftm_hal.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\gpio\fsl_gpio_hal.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\i2c\fsl_i2c_hal.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\llwu\fsl_llwu_hal.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\lptmr\fsl_lptmr_hal.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\lpuart\fsl_lpuart_hal.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\mcg\fsl_mcg_hal.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\mcg\fsl_mcg_hal_modes.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\utilities\src\fsl_misc_utilities.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\utilities\src\fsl_os_abstraction_mbed.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\osc\fsl_osc_hal.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\pdb\fsl_pdb_hal.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\drivers\pit\common\fsl_pit_common.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\drivers\pit\src\fsl_pit_driver.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\pit\fsl_pit_hal.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\drivers\pit\src\fsl_pit_irq.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\pmc\fsl_pmc_hal.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\port\fsl_port_hal.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\rtc\fsl_rtc_hal.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\sai\fsl_sai_hal.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\sdhc\fsl_sdhc_hal.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\sim\fsl_sim_hal.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\smc\fsl_smc_hal.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\uart\fsl_uart_hal.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_KPSDK_CODE\hal\wdog\fsl_wdog_hal.c</name>
          </file>
        </group>
        <group>
          <name>mbed_hal</name>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\analogin_api.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\analogout_api.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\gpio_api.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\gpio_irq_api.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\gpio_object.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\i2c_api.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\objects.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\PeripheralPins.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\pinmap.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\port_api.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\PortNames.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\pwmout_api.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\rtc_api.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\serial_api.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\sleep.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\spi_api.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\us_ticker.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_K22F\cmsis.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_K22F\cmsis_nvic.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_K22F\cmsis_nvic.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_K22F\device.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_K22F\MK22F51212\fsl_clock_K22F51212.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_K22F\MK22F51212\fsl_clock_K22F51212.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_K22F\MK22F51212\fsl_sim_hal_K22F51212.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_K22F\MK22F51212\fsl_sim_hal_K22F51212.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_K22F\mbed_overrides.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_K22F\PeripheralNames.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_K22F\PeripheralPins.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_KPSDK_MCUS\TARGET_K22F\PinNames.h</name>
        </file>
      </group>
    </group>
    <group>
      <name>startup</name>
      <file>
        <name>$PROJ_DIR$\..\src\startup\startup.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\startup\startup.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\startup\MK22F51212\iar\startup_MK22F51212.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\startup\MK22F51212\system_MK22F51212.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\startup\MK22F51212\system_MK22F51212.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>test</name>
    <file>
      <name>$PROJ_DIR$\..\test\src\basic_test.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\test\src\debug_uart.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\test\src\debug_uart.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\test\src\kernel_tests.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\test\src\test_mutex_1.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\test\src\test_queue_1.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\test\src\test_sem_1.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\test\src\test_sleep_1.cpp</name>
    </file>
  </group>
</project>


