<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\argon_test_K60.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\argon_test_K64.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\argon_test_KL25.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\led_ringcoder_test_KL25.ewp</path>
  </project>
  <batchBuild/>
</workspace>


