# IAR project argon_test_KL43.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL43Z256xxx4 Freescale MKL43Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: CPU_MKL43Z256VLH4; DEBUG; TARGET_KL43Z; TOOLCHAIN_IAR
  ICCARM.CCDiagSuppress: Pa050, Pa093
  ICCARM.CCIncludePath2: ..\src; ..\src\include; ..\src\include\device; ..\src\include\device\MKL43Z4; ..\src\startup; ..\src\startup\MKL43Z4; ..\src\argon\cortex_m; ..\src\drivers; ..\src\mbed\hal; ..\src\mbed\api; ..\src\mbed\targets\TARGET_KLXX; ..\src\mbed\targets\TARGET_KLXX\TARGET_KL43Z
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: argon_test_KL43.srec
  ILINK.IlinkOutputFile: basic_test.out
  ILINK.IlinkConfigDefines: __heap_size__=8192
  ILINK.IlinkIcfFile: config\MKL43Z256xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MKL43Z256VLH4; NDEBUG; TARGET_KL43Z; TOOLCHAIN_IAR
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: argon_test.srec
  group src/argon
    ../src/argon/: ar_classes.h ar_kernel.h argon.h
  group src/argon/cortex_m
    ../src/argon/cortex_m/: ar_handlers_cm0p.s ar_main_thread.cpp ar_port.cpp ar_port.h
  group src/argon/src
    ../src/argon/src/: ar_channel.cpp ar_config.h ar_internal.h ar_kernel.cpp ar_mutex.cpp ar_queue.cpp ar_sem.cpp ar_thread.cpp ar_timer.cpp
  group src/drivers/MMA8451Q
    ../src/drivers/MMA8451Q/: MMA8451Q.cpp MMA8451Q.h
  group src/include
    ../src/include/: fsl_platform_common.h fsl_platform_status.h fsl_platform_types.h
  group src/mbed/common
    ../src/mbed/common/: assert.c board.c BusIn.cpp BusInOut.cpp BusOut.cpp CallChain.cpp CAN.cpp error.c Ethernet.cpp exit.c FileBase.cpp FileLike.cpp FilePath.cpp FileSystemLike.cpp FunctionPointer.cpp gpio.c I2C.cpp I2CSlave.cpp InterruptIn.cpp InterruptManager.cpp LocalFileSystem.cpp mbed_interface.c pinmap_common.c RawSerial.cpp retarget.cpp rtc_time.c semihost_api.c Serial.cpp SerialBase.cpp SPI.cpp SPISlave.cpp Stream.cpp Ticker.cpp Timeout.cpp Timer.cpp TimerEvent.cpp us_ticker_api.c wait_api.c
  group src/mbed/kl43
    ../src/mbed/targets/TARGET_KLXX/: analogin_api.c analogout_api.c clk_freqs.h gpio_api.c gpio_object.h i2c_api.c objects.h PeripheralPins.h pinmap.c port_api.c PortNames.h pwmout_api.c rtc_api.c sleep.c us_ticker.c
    ../src/mbed/targets/TARGET_KLXX/TARGET_KL43Z/: cmsis_nvic.c device.h gpio_irq_api.c mbed_overrides.c PeripheralNames.h PeripheralPins.c PinNames.h serial_api.c spi_api.c
  group src/startup
    ../src/startup/: startup.c startup.h
    ../src/startup/MKL43Z4/iar/: startup_MKL43Z4.s
    ../src/startup/MKL43Z4/: system_MKL43Z4.c system_MKL43Z4.h
  group test
    ../test/src/: basic_test.cpp kernel_tests.h test_mutex_1.cpp test_queue_1.cpp test_sem_1.cpp test_sleep_1.cpp
    ../src/argon/test/src/: kernel_test.cpp
    ../src/drivers/nrf/: nrf.cpp
