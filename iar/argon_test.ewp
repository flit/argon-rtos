# IAR project argon_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: CPU_MKL25Z128VLK4; DEBUG
  ICCARM.CCDiagSuppress: Pa050, Pa093
  ICCARM.CCIncludePath2: ..\src; ..\src\include; ..\src\include\device; ..\src\startup; ..\src\os\cortex_m; ..\src\drivers; ..\src\mbed\hal; ..\src\mbed\api; ..\src\mbed\targets\TARGET_KL25Z
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: argon_test.srec
  ILINK.IlinkOutputFile: argon_test.out
  ILINK.IlinkIcfFile: config\128KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CPU_MKL25Z128VLK4; NDEBUG
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\src; ..\src\include; ..\src\include\device; ..\src\startup; ..\src\os\cortex_m; ..\src\drivers
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: basic_test.out
  group src/drivers/uart
    ../src/drivers/uart/: uart0.c uart0.h
  group src/include
    ../src/include/: fsl_platform_common.h fsl_platform_status.h fsl_platform_types.h
  group src/mbed/common
    ../src/mbed/common/: board.c BusIn.cpp BusInOut.cpp BusOut.cpp CallChain.cpp CAN.cpp Ethernet.cpp exit.c FileBase.cpp FileLike.cpp FilePath.cpp FileSystemLike.cpp FunctionPointer.cpp I2C.cpp I2CSlave.cpp InterruptIn.cpp InterruptManager.cpp LocalFileSystem.cpp mbed_interface.c pinmap_common.c RawSerial.cpp retarget.cpp rtc_time.c semihost_api.c Serial.cpp SerialBase.cpp SPI.cpp SPISlave.cpp Stream.cpp Ticker.cpp Timeout.cpp Timer.cpp TimerEvent.cpp us_ticker_api.c wait_api.c
  group src/mbed/kl25
    ../src/mbed/targets/TARGET_KL25Z/: analogin_api.c analogout_api.c cmsis.h cmsis_nvic.c cmsis_nvic.h device.h gpio_api.c gpio_irq_api.c gpio_object.h i2c_api.c objects.h PeripheralNames.h pinmap.c PinNames.h port_api.c PortNames.h pwmout_api.c rtc_api.c serial_api.c sleep.c spi_api.c us_ticker.c
  group src/os
    ../src/os/: ar_kernel.h
  group src/os/cortex_m
    ../src/os/cortex_m/: ar_handlers.s ar_port.cpp ar_port.h
  group src/os/src
    ../src/os/src/: ar_kernel.cpp ar_mutex.cpp ar_named_object.cpp ar_queue.cpp ar_sem.cpp ar_thread.cpp
  group src/startup
    ../src/startup/: crt0.s startup.c startup.h
    ../src/startup/MKL25Z4/: startup_MKL25Z4.s system_MKL25Z4.c
  group test
    ../test/src/: basic_test.cpp debug_uart.cpp debug_uart.h kernel_tests.h test_queue_1.cpp test_sem_1.cpp test_sleep_1.cpp
