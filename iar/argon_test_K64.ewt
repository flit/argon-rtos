<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>src</name>
    <group>
      <name>drivers</name>
      <group>
        <name>MMA8451Q</name>
        <file>
          <name>$PROJ_DIR$\..\src\drivers\MMA8451Q\MMA8451Q.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\drivers\MMA8451Q\MMA8451Q.h</name>
        </file>
      </group>
      <group>
        <name>uart</name>
        <file>
          <name>$PROJ_DIR$\..\src\drivers\uart\scuart.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\drivers\uart\scuart.h</name>
        </file>
      </group>
    </group>
    <group>
      <name>include</name>
      <file>
        <name>$PROJ_DIR$\..\src\include\fsl_platform_common.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\include\fsl_platform_status.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\include\fsl_platform_types.h</name>
      </file>
    </group>
    <group>
      <name>mbed</name>
      <group>
        <name>common</name>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\board.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\BusIn.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\BusInOut.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\BusOut.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\CallChain.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\CAN.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\Ethernet.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\exit.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\FileBase.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\FileLike.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\FilePath.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\FileSystemLike.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\FunctionPointer.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\I2C.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\I2CSlave.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\InterruptIn.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\InterruptManager.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\LocalFileSystem.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\mbed_interface.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\pinmap_common.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\RawSerial.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\retarget.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\rtc_time.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\semihost_api.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\Serial.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\SerialBase.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\SPI.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\SPISlave.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\Stream.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\Ticker.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\Timeout.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\Timer.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\TimerEvent.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\us_ticker_api.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\common\wait_api.c</name>
        </file>
      </group>
      <group>
        <name>k60</name>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_K60DZ10\analogin_api.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_K60DZ10\analogout_api.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_K60DZ10\cmsis.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_K60DZ10\cmsis_nvic.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_K60DZ10\cmsis_nvic.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_K60DZ10\device.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_K60DZ10\gpio_api.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_K60DZ10\gpio_irq_api.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_K60DZ10\gpio_object.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_K60DZ10\i2c_api.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_K60DZ10\objects.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_K60DZ10\PeripheralNames.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_K60DZ10\pinmap.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_K60DZ10\PinNames.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_K60DZ10\port_api.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_K60DZ10\PortNames.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_K60DZ10\pwmout_api.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_K60DZ10\rtc_api.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_K60DZ10\serial_api.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_K60DZ10\sleep.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_K60DZ10\spi_api.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\mbed\targets\TARGET_K60DZ10\us_ticker.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>os</name>
      <group>
        <name>cortex_m</name>
        <file>
          <name>$PROJ_DIR$\..\src\os\cortex_m\ar_handlers_cm4.s</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\os\cortex_m\ar_port.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\os\cortex_m\ar_port.h</name>
        </file>
      </group>
      <group>
        <name>src</name>
        <file>
          <name>$PROJ_DIR$\..\src\os\src\ar_config.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\os\src\ar_internal.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\os\src\ar_kernel.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\os\src\ar_mutex.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\os\src\ar_queue.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\os\src\ar_sem.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\os\src\ar_thread.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\os\src\ar_timer.cpp</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\src\os\ar_classes.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\os\ar_kernel.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\os\argon.h</name>
      </file>
    </group>
    <group>
      <name>startup</name>
      <file>
        <name>$PROJ_DIR$\..\src\startup\crt0.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\startup\startup.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\startup\startup.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\startup\MK64F12\iar\startup_MK64F12.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\startup\MK64F12\system_MK64F12.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>test</name>
    <file>
      <name>$PROJ_DIR$\..\test\src\basic_test.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\test\src\debug_uart.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\test\src\debug_uart.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\test\src\kernel_tests.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\test\src\test_mutex_1.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\test\src\test_queue_1.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\test\src\test_sem_1.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\test\src\test_sleep_1.cpp</name>
    </file>
  </group>
</project>


